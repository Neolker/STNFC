# IAR project NFC08A1_PollingTagDetect.ewp, settings and files
configuration NFC08A1_PollingTagDetect (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0B1RE ST STM32G0B1RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: ST25R3916B; USE_HAL_DRIVER; STM32G0B1xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/ST25R3916; ../../../../../Drivers/BSP/NFC08A1; ../../../../../Middlewares/ST/rfal/Inc; ../../../../../Middlewares/ST/rfal/Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../Binary/NFC08A1_PollingTagDetect.bin
  ILINK.IlinkOutputFile: NFC08A1_PollingTagDetect.out
  ILINK.IlinkIcfFile: stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0b1xx.s
  group Application/User
    ../Src/: main.c nfc_conf.c analogConfigTbl_NFC08A1.c demo_ce.c demo_polling.c logger.c app_x-cube-nfcx.c stm32g0xx_nucleo_bus.c stm32g0xx_nucleo.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ST25R3916/: rfal_rfst25r3916.c st25r3916.c st25r3916_aat.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c timer.c
  group Drivers/BSP/NFC
    ../../../../../Drivers/BSP/NFC08A1/: nfc08a1.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Middlewares/X-CUBE-NFC6/Wireless/MID_LIB/RFAL/Default_Config
    ../../../../../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_cd.c rfal_dpo.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
